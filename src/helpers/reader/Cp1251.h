#pragma once

// Windows-1251 <-> UTF-8 for book titles and the PC preview tool.

#include <stddef.h>
#include <stdint.h>

static const uint16_t CP1251_HIGH[128] = {
  0x0402, 0x0403, 0x201A, 0x0453, 0x201E, 0x2026, 0x2020, 0x2021,
  0x20AC, 0x2030, 0x0409, 0x2039, 0x040A, 0x040C, 0x040B, 0x040F,
  0x0452, 0x2018, 0x2019, 0x201C, 0x201D, 0x2022, 0x2013, 0x2014,
  0x0000, 0x2122, 0x0459, 0x203A, 0x045A, 0x045C, 0x045B, 0x045F,
  0x00A0, 0x040E, 0x045E, 0x0408, 0x00A4, 0x0490, 0x00A6, 0x00A7,
  0x0401, 0x00A9, 0x0404, 0x00AB, 0x00AC, 0x00AD, 0x00AE, 0x0407,
  0x00B0, 0x00B1, 0x0406, 0x0456, 0x0491, 0x00B5, 0x00B6, 0x00B7,
  0x0451, 0x2116, 0x0454, 0x00BB, 0x0458, 0x0405, 0x0455, 0x0457,
  0x0410, 0x0411, 0x0412, 0x0413, 0x0414, 0x0415, 0x0416, 0x0417,
  0x0418, 0x0419, 0x041A, 0x041B, 0x041C, 0x041D, 0x041E, 0x041F,
  0x0420, 0x0421, 0x0422, 0x0423, 0x0424, 0x0425, 0x0426, 0x0427,
  0x0428, 0x0429, 0x042A, 0x042B, 0x042C, 0x042D, 0x042E, 0x042F,
  0x0430, 0x0431, 0x0432, 0x0433, 0x0434, 0x0435, 0x0436, 0x0437,
  0x0438, 0x0439, 0x043A, 0x043B, 0x043C, 0x043D, 0x043E, 0x043F,
  0x0440, 0x0441, 0x0442, 0x0443, 0x0444, 0x0445, 0x0446, 0x0447,
  0x0448, 0x0449, 0x044A, 0x044B, 0x044C, 0x044D, 0x044E, 0x044F,
};

inline uint32_t cp1251ToUnicode(uint8_t b) {
  return b < 0x80 ? b : CP1251_HIGH[b - 0x80];
}

// 0 when the code point has no 1251 byte.
inline uint8_t unicodeToCp1251(uint32_t cp) {
  if (cp < 0x80) return (uint8_t)cp;
  if (cp >= 0x0410 && cp <= 0x044F) return (uint8_t)(cp - 0x0410 + 0xC0);
  for (int i = 0; i < 64; i++) if (CP1251_HIGH[i] == cp) return (uint8_t)(0x80 + i);
  return 0;
}

// UTF-8 -> 1251 for menu labels; unknown characters become '?'.
inline void utf8ToCp1251(char* dest, size_t dest_size, const char* src) {
  if (dest_size == 0) return;
  size_t j = 0;
  const uint8_t* p = (const uint8_t*)src;
  while (*p && j + 1 < dest_size) {
    uint32_t cp;
    int n;
    if (*p < 0x80) { cp = *p; n = 1; }
    else if ((*p & 0xE0) == 0xC0) { cp = *p & 0x1F; n = 2; }
    else if ((*p & 0xF0) == 0xE0) { cp = *p & 0x0F; n = 3; }
    else { cp = *p & 0x07; n = 4; }
    int k = 1;
    for (; k < n && (p[k] & 0xC0) == 0x80; k++) cp = (cp << 6) | (p[k] & 0x3F);
    p += k;
    uint8_t b = unicodeToCp1251(cp);
    dest[j++] = (char)(b ? b : '?');
  }
  dest[j] = 0;
}

// Converts a zero-terminated 1251 string; always terminates dest.
inline void cp1251ToUtf8(char* dest, size_t dest_size, const char* src) {
  if (dest_size == 0) return;
  size_t j = 0;
  for (const uint8_t* p = (const uint8_t*)src; *p; p++) {
    uint32_t cp = cp1251ToUnicode(*p);
    if (cp == 0 || cp == 0xAD) continue;
    if (cp == 0xA0) cp = ' ';
    char tmp[3];
    int n;
    if (cp < 0x80) { tmp[0] = (char)cp; n = 1; }
    else if (cp < 0x800) { tmp[0] = (char)(0xC0 | (cp >> 6)); tmp[1] = (char)(0x80 | (cp & 0x3F)); n = 2; }
    else { tmp[0] = (char)(0xE0 | (cp >> 12)); tmp[1] = (char)(0x80 | ((cp >> 6) & 0x3F)); tmp[2] = (char)(0x80 | (cp & 0x3F)); n = 3; }
    if (j + n >= dest_size) break;
    for (int k = 0; k < n; k++) dest[j++] = tmp[k];
  }
  dest[j] = 0;
}
